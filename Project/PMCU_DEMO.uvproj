# Keil uVision project PMCU_DEMO.uvproj, settings and files
target PMCU_X0 (MCS-51)
  device: R8051XC CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: PMCU_DEMO_V01 +hex
  AfterMake: .\auto_copy.bat
  c flags: Optimize=8
  c include: ..\App;..\App\manager;..\App\battery;..\App\pwm;..\App\charge;..\App\volt;..\App\rload;..\App\util;..\App\key;..\App\led_screen;..\Bsp\inc;..\stdDriver;..\Pmcu_Lib\inc;..\App\screen
  link misc: REMOVEUNUSED
  group main
    ../App/: main.c local_process.c user_config.h
  group manager
    ../App/manager/: manager.c pmu.c userdatas.c
  group battery
    ../App/battery/: battery.c
  group charge
    ../App/charge/: charger_usb.c
  group key mic
    ../App/key/: key_mic.c
  group led_screen
    ../App/led_screen/: led_ctrl.c led_show.c led_screen_common.c screen_x1_driver.c screen_ctrl_mode.c screen_show.c magic_led_driver.c
  group rload
    ../App/rload/: rl_det.c
  group volt
    ../App/volt/: volt_out.c
  group util
    ../App/util/: util_filter.c util_printf.c util_queue.c util_timepass.c
  group bsp
    ../Bsp/src/: bsp_adc.c bsp_charge.c bsp_gpio.c bsp_mic.c bsp_pwm.c bsp_timer.c bsp_uart.c bsp_wakeup.c bsp_wdt.c
  group pmcu_lib
    ../Pmcu_Lib/inc/: compiler_defs.h pmcu_x0_adc.h pmcu_x0_charge.h pmcu_x0_config.h pmcu_x0_delay.h pmcu_x0_gpio.h pmcu_x0_mic.h pmcu_x0_mos.h pmcu_x0_motor.h pmcu_x0_pwm.h pmcu_x0_sys.h pmcu_x0_timer.h pmcu_x0_uart.h pmcu_x0_wakeup.h pmcu_x0_wdt.h pmcu_x0_include.h
    ../Pmcu_Lib/lib/: pmcu_x0_lib_v14.LIB
  group startup
    ../Startup/: STARTUP.A51
